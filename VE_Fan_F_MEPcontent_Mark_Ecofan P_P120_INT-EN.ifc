Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2017-11-01T15:49:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 01 15:49:27 2017 * Host: B3ROBRAWR3331 * Database: C:\Users\RVI\AppData\Local\Temp\{C320DC40-B23E-40F4-975F-DF28BF0379B0}\ifc * Database version: 5507 * Database creation date: Wed Nov 01 15:49:27 2017 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Nov 01 15:49:27 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 01 15:49:27 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFan: P120, VE_Fan_F_MEPcontent_Mark_Ecofan P_INT-EN:P120:1369894
In: V00
Type - PredefinedType: CENTRIFUGALRADIAL; Material: Color RAL 9010
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Diameter: 1220 mm; Height: 500 mm
Type - Electrical - Consumed Current: 0.5 A; Motor Rating: 65 W; Supply Voltage (50Hz): 240 V
Type - Identity Data - Article Description: ECOFAN with thermostat; Article Type: P120; Content Supplier URL: www.mepcontent.eu; Copyright: © Trimble Europe BV; Custom: no; Description: ECOFAN with thermostat; EMCS Version: 3.0; ETIM Article Class: EC011012; Family Version: 11.06; GTIN: 87193339081204; Manufacturer: Mark; Manufacturer Art. No.: 5990812; Manufacturer URL: https://www.markclimate.com/ventilation-and-recirculation-equipment/ecofan-p/; MEPcontent Class: FAN; Model: P120; OmniClass Number: 23.75.35.17.17.11; OmniClass Title: Ceiling Fans; Product Line: Mark; Revit Version: 2018; Type Name: P120; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - White: Color RAL 9010
Type - Mechanical - Air Displacement: 0.005 m3/s; Fan: 1220 mm; Motor Speed: 290; Suspension Height: 4-7 m; Weight: 4.4
Type - Other - Category: Mechanical Equipment; Blade Diameter: 61 mm; Blade Length: 549 mm; Blade Reduced: 15.25 mm; Blade Reduced 2: 30.5 mm; Blade Void: 63 mm; B Reduced: 610 mm; Family Name: VE_Fan_F_MEPcontent_Mark_Ecofan P_INT-EN
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Elevation: 0 mm
Dimensions - Area: 0.303808 m2; Volume: 0.00505268 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Power
Other - Family: VE_Fan_F_MEPcontent_Mark_Ecofan P_INT-EN: P120; Family and Type: VE_Fan_F_MEPcontent_Mark_Ecofan P_INT-EN: P120; Type: VE_Fan_F_MEPcontent_Mark_Ecofan P_INT-EN: P120; Type Id: VE_Fan_F_MEPcontent_Mark_Ecofan P_INT-EN: P120
Phasing - Phase Created: 4. Plan over 10 jaar
